# Keil uVision project STM32F103.uvprojx, settings and files
target STM32F103 (6220000::V6.22::ARMCLANG)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: STM32F103 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\SyntropicOS;..\flash;..\Library;..\TP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FLASH
    ../SyntropicOS/: syn_param.c syn_crc.c syn_assert.c
  group AA
    ../flash/: flash.c
  group TP
    ../TP/: isotp.c isotp_user.c isotp_socket.c
  group LIB
    ../Library/: crc16.c DataLookupTable.c DataTransmissionFunctionalUnit.c DiagnosticAndCommunicationManagementFunctionalUnit.c DTC_LookupTable.c InputOutputControlFunctionalUnit.c interface_clock.c negativeResponse.c NvmEmulator.c RoutineFunctionalUnit.c ServiceLookupTable.c SessionAndServiceControl.c StoredDataTransmissionFunctionalUnit.c uds.c UploadDownloadFunctionalUnit.c
software components: CMSIS:CORE 6.2.0, Compiler:I/O:STDIN 1.2.0
